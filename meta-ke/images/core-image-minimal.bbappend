IMAGE_INSTALL += "hwlocal hwgit"